# Keil uVision project Retarget_IO.uvprojx, settings and files
target GCC (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Template_GCC
  group Source
    ../: main.c
    ./../: retarget_stdio.c
  group Validation Framework
    ../../TestFramework/Source/: tf_main.c tf_report.c
  group Test Suite
    ../../TestSuite/: test_config.c test.c tc_stdio.c
  group IO
    ../: retarget_fs.c
target GCC nostartfiles (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: Template_GCC
target GCC nano (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: Template_GCC
target GCC nano nostartfiles (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: Template_GCC
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Compiler:File Interface:Custom 1.0.0, Compiler:I/O:File 1.0.0, Compiler:I/O:STDERR 1.0.0, Compiler:I/O:STDIN 1.0.0, Compiler:I/O:STDOUT 1.0.0, Compiler:OS Interface:CMSIS-RTOS2 1.0.0, Device:Startup 2.0.3
