# Keil uVision project Retarget_IO.uvprojx, settings and files
target Arm (6190000::V6.19::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Retarget_IO
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\;..\..\TestFramework\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
  group Source
    ../: main.c retarget_stdio.c
  group Validation Framework
    ../../TestFramework/Source/: tf_main.c tf_report.c
  group Test Suite
    ../../TestSuite/: test_config.c test.c tc_stdio.c
  group IO
    ../: file_user.c
software components: CMSIS:CORE 5.6.0, CMSIS:Event Recorder 1.5.2, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:I/O:File 1.0.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Compiler:OS Interface 1.0.0, Device:Startup 2.0.3, File System:CORE 6.15.3, File System:Drive:RAM 6.15.3
