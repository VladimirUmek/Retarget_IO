# Keil uVision project Retarget_IO.uvprojx, settings and files
target GCC (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.1-dev116
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Template_GCC
  group Source
    ../: main.c
    ./../: retarget_stdio.c
  group Validation Framework
    ../../TestFramework/Source/: tf_main.c tf_report.c
  group Test Suite
    ../../TestSuite/: test.c test.h test_config.c test_config.h tc_stdio.c
  group IO
    ../: retarget_fs.c
target GCC nostartfiles (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.1-dev116
  cpu: as above
  output: Template_GCC
target GCC nano (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.1-dev116
  cpu: as above
  output: Template_GCC
target GCC nano nostartfiles (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.1-dev116
  cpu: as above
  output: Template_GCC
software components: CMSIS-Compiler:File Interface:Custom 1.0.0, CMSIS-Compiler:I/O:File 1.0.0, CMSIS-Compiler:I/O:STDERR 1.0.0, CMSIS-Compiler:I/O:STDIN 1.0.0, CMSIS-Compiler:I/O:STDOUT 1.0.0, CMSIS-Compiler:OS Interface:CMSIS-RTOS2 1.0.0, CMSIS:CORE 5.7.0, CMSIS:RTOS2:Keil RTX5 5.7.0, Device:Startup 2.0.3
